Commit message: added todo

File: urdf/_old.urdf (robot description, URDF)
Before this commit: robot hrp4, 66 links, 65 joints
Links:
- link l_sole: geometry 
- link r_sole: geometry 
